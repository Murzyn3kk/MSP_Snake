<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Snake.ewp</path>
    </project>
    <batchBuild />
</workspace>
